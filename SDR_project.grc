options:
  parameters:
    generate_options: qt_gui
    id: SDR_project
    output_language: python
    title: SDR_project
  states: {}

blocks:
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (1)*window_size
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (1)*window_size
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '5220000000'
    gain0: '30'
    rx_agc0: Disabled
    samp_rate: '20000000'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_divide_xx_0, '1']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
