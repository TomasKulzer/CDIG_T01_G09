options:
  parameters:
    generate_options: qt_gui
    id: SDR_project
    output_language: python
    title: SDR_project
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\douto\Desktop\universidade\CDIG\Wifi_Project_Baseband_recordings\Sample1_20MHz_Channel36.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ''
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: fff
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    bw: 10e6
    debug: 'False'
    freq: 5.89e9
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.8'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '5220000000'
    gain1: '''manual'''
    manual_gain1: '30'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '2000'
    srate: '100000000'
    type: float
    ymax: '1.1'
    ymin: '0'
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', ieee802_11_sync_short_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_divide_xx_0, '1']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_parse_mac_0, out, network_socket_pdu_0, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
